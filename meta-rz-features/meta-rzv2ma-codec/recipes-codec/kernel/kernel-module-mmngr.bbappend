FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/:"

SRC_URI_append_rzv2ma = " \
    file://0012-mmngr-module-mmngr_drv-add-RZV2MA-for-rzg2l_match.patch \
"

