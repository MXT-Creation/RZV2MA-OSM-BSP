TOOLCHAIN_TARGET_TASK_append = " drp "
IMAGE_INSTALL_append = " \
    kernel-module-mmngr \
    kernel-module-mmngrbuf \
    "
